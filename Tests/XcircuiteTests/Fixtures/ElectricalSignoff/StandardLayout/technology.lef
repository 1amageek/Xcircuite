VERSION 5.8 ;
UNITS
  DATABASE MICRONS 1000 ;
END UNITS
LAYER M1
  TYPE ROUTING ;
  DIRECTION HORIZONTAL ;
  PITCH 0.28 ;
  WIDTH 0.14 ;
  SPACING 0.14 ;
  AREA 0.058 ;
END M1
LAYER VIA1
  TYPE CUT ;
  SPACING 0.17 ;
END VIA1
END LIBRARY
