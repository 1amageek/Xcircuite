VERSION 5.8 ;
UNITS
  DATABASE MICRONS 1000 ;
END UNITS
LAYER ACTIVE
  TYPE MASTERSLICE ;
END ACTIVE
LAYER M1
  TYPE ROUTING ;
  DIRECTION HORIZONTAL ;
  PITCH 0.2 ;
  WIDTH 0.2 ;
  SPACING 0.2 ;
END M1
MACRO nmos
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 1 BY 1 ;
END nmos
END LIBRARY
